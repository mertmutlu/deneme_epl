# Keil uVision project Project.uvprojx, settings and files
target STM32F3348-Discovery_Demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F334C8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00008000) IRAM(0x20000000,0x00030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F3348-Discovery_Demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F334x8,
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32F3348-Discovery;..\M7
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x30000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f334x8.s
  group STM32F30x_StdPeriph_Driver
    ../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group STM32F3348-Discovery
    ../../../Utilities/STM32F3348-Discovery/: stm32f3348_discovery.c
  group User
    ./: main.c stm32f3xx_it.c system_stm32f30x.c relay.c 25LC512.C ads1232.c lcd.c task_press.c task_test.c fire.c calibration_press.c
